# Repository project-unicollabo/UkiUkiCore

File README.md:

# UkiUkiCore

**UkiUkiduino シリーズ専用 Arduino コア**  
USB ネイティブな新世代 AVR(AVR DU シリーズ)を搭載した Arduino 互換ボード  
「UkiUkiduino」シリーズのためのボードサポートパッケージ(Arduino core)です。  
UkiUkiduino シリーズは VTuber「浮々ゆにこ」のファングッズとして開発されたボードです。  

UkiUkiduino シリーズは、定番の Arduino 互換ボードを **USB を内蔵した新世代 AVR** で置き換えたボード群です。  
USB-シリアル変換チップを別途搭載せず、マイコン単体で PC と直接つながります。  
UkiUkiCore は、これらのボードを Arduino IDE で開発するための専用コアで、  
[WazamonoCore](https://github.com/ws-asahi/WazamonoCore)から **UkiUkiduino シリーズに必要な部分だけを残して再構成** しています。

> ⚠️ **開発版(v0.0.5)です。** API・ボード定義・ブートローダは予告なく変更されることがあります。

---

## 対応ボード

| ボード | MCU | フォームファクタ | 状態 |
|--------|-----|------------------|------|
| [**UkiUkiduino**](megaavr/extras/UkiUkiduino.md) | AVR64DU32 | Arduino Uno R3 互換 / USB-C | 🔧 試作中 |
| [**UkiUkiduino Pony**](megaavr/extras/UkiUkiduinoPony.md) | AVR64DU32 | Pro Micro 互換 / USB-C | 🔧 製造中 |

> ピン配置・オンボード LED / ボタン・電源など、ボードごとの詳細は上記の各ページを参照してください。  
> このページにはコア全体に共通する内容をまとめています。  

---

## 心臓部 - AVR64DU32

両機種とも USB を内蔵した新世代 AVR「**AVR64DU32**」を採用しています。  

| 項目 | 値 |
|------|----|
| Flash | 64 KB(うちスケッチ用 60 KB/USB ブートローダ 4 KB) |
| SRAM | 8 KB |
| EEPROM | 256 B |
| USERROW | 512 B |
| 最大動作周波数 | 24 MHz |
| USB | USB 2.0 Full-Speed デバイス |
| USB-EP | IN16 / OUT16 (合計32) |
| ADC | 10-bit 170 ksps × 1 |
| タイマ | 16-bit TCA0 ×1 / 16-bit TCB ×2 |
| USART | 2 |
| SPI | 2 |
| I2C | 1 |
| 外部割り込み | 全ピン |
| CCL(LUT) | 4 |
| イベントシステム | 6 チャネル |
| アナログコンパレータ(AC) | 1 |
| 電源 | USB 5V / DC ジャック 7–12V |
| 書き込み | USB ブートローダー / UPDI |

<sub>諸元はデータシート DS40002548B（AVR64DU32）に基づく。</sub>

---

## 特長

- **クロックと処理速度** — 24 MHz 動作(Uno の 16 MHz 比で 1.5 倍)に加え、  
  AVRxt コアは一部命令のタイミングが改善されており、ベンチマークでは同一クロックでも約 12% 高速です。  
- **記憶領域の刷新** - 新しく USERROW / Flash などの記憶領域が追加(一方 EEPROM 容量は 256 B へ減少)。  
- **USB ネイティブ** - 追加の USB-シリアル変換チップが不要。`Serial` がそのまま USB仮想シリアルポートになります。  
  `Serial` がそのまま USB CDC 仮想シリアルとなり、USB HID(キーボード/マウス)や USB-MIDI にもなれます。  
- **USB ブートローダ** - USB-CDC(STK500v1)経由でスケッチを書き込み。  
- **HID / MIDI 対応** - USB キーボード・マウス等の HID、および USB-MIDI などをサポート。  
- **高い互換性** - 同系統の MCU を採用しているため UnoR3 や ProMicro のコードをほぼそのまま実装可能。  
- **各ピンの出力能力** - ピンあたりの電流出力は 20 mA を維持しており、UnoR4 の 8 mA では動かせない外部機器も動作可能。  
- **全ピンアナログ入力対応** - 全てのデジタル入出力ピンでアナログ値の読取りが可能。  
- **拡張された PWM 出力** - TCA0 の 6 本に加え、LUT を使用した択一式 PWM(TCB1)を備え、  
  Uno R3 / Pro Micro 本来の PWM ピンをすべて再現した上で追加の PWM ピンを提供。  
- **UPDI 対応** - UPDI デバッガーで動作中の MCU にアクセス可能(UkiUkiduino: Power ヘッダ 1 番ピン / UkiUkiduino Pony: UPDI ヘッダ)。  
- **ネイティブ avr-gcc 対応** - DxCore と異なる点として最新の avr-gcc コンパイラを使用（今後も順次更新されます）。  
- **追加の シリアル通信** — 2 系統の UART シリアル通信と2系統の SPI を利用可能です。  
- **フルカラーLED搭載** - `LED_BUILTIN` と連動して `setBLEDColor()` で色指定できる LED を両機種に搭載。  
- **オンボードボタン搭載** - `BTN_BUILTIN` で追加部品なしに入力を試せます。  

---

### 留意点

- **EEPROM 容量は ATmega328P / ATmega32U4 のほうが大きい**(1 KB 対 256 B)。
- 多くの不揮発データを保存する用途では保存方法の見直し(User Row やフラッシュの活用)が必要になる場合があります
  (後述「データ記憶領域」参照)。

---

## インストール

### ボードマネージャ経由(推奨)

1. Arduino IDE の **ファイル > 基本設定 > 追加のボードマネージャの URL** に以下を追加します。

   ```
   https://project-unicollabo.github.io/UkiUkiCore/package_ukiuki_index.json
   ```

2. **ツール > ボード > ボードマネージャ** で「**UkiUkiCore**」を検索してインストールします。
3. コア本体に加えて、専用ツールチェーン(avr-gcc 15.2.0 / avrdude 8.1)が自動的にダウンロード・設定されます。  
   追加の設定は不要です。

詳しい手順・手動インストール(開発者向け)は [Installation.md](Installation.md) を参照してください。  
バージョンごとの変更内容は [ChangeLog.md](ChangeLog.md) を参照してください。

### 必要環境

- Arduino IDE 1.8.13 以降、または 2.x
- ブートローダーの書き換えには UPDI プログラマ(PICkit 4/5、Atmel-ICE、jtag2updi 等)が必要になります。

> Linux をお使いの場合、Arduino IDE は必ず [arduino.cc](https://www.arduino.cc) 配布版を使用してください。  
> ディストリのパッケージマネージャ版は改変されており、正常に動作しません。  

---

## クイックスタート

1. **ツール > ボード > UkiUkiCore** から **UkiUkiduino** または **UkiUkiduino Pony** を選択
2. USB ケーブルで接続し、ボードが接続された COM ポートを選択して書き込み

以下のスケッチは両機種で無改変で動作します(`LED_BUILTIN` / `BTN_BUILTIN` の番号はボードごとに異なりますが、名前で指定すれば共通です)。

**Lチカ:**
```cpp
void setup() {
  pinMode(LED_BUILTIN, OUTPUT);
}
void loop() {
  digitalWrite(LED_BUILTIN, !digitalRead(LED_BUILTIN));
  delay(500);
}
```

**ボタン連動:**
```cpp
void setup() {
  pinMode(BTN_BUILTIN, INPUT);
  pinMode(LED_BUILTIN, OUTPUT);
}
void loop() {
  digitalWrite(LED_BUILTIN, digitalRead(BTN_BUILTIN));  //ボタン状態をLEDへ反映
}
```

**LED色変更:**
```cpp
void setup() {
  pinMode(LED_BUILTIN, OUTPUT);
  setBLEDColor(255, 0, 0); //赤色指定(標準色は黄色)
}
void loop() {
  digitalWrite(LED_BUILTIN, !digitalRead(LED_BUILTIN));
  delay(500);
}
```

---

## オンボードフルカラー LED(共通 API)

両機種のオンボード LED は WS2812 系のフルカラー LED で、`LED_BUILTIN` への `digitalWrite()` に連動して点灯・消灯します。  
点灯時の色と明るさは以下の API で変更できます(コア組み込み、include 不要)。

```cpp
setBLEDColor(Yellow);          // 色名で指定(既定の明るさ 40)
setBLEDColor(Yellow, 255);     // 色名 + 明るさ 0〜255
setBLEDColor(r, g, b);         // RGB 値をそのまま表示(明るさスケーリングなし)
```

色名: `Red` `Green` `Blue` `Yellow` `Orange` `Cyan` `Magenta` `Purple` `Pink` `White`  

> 点灯中に呼ぶと即時反映、消灯中に呼ぶと次の点灯から反映されます。  
> `digitalWrite(LED_BUILTIN, ...)` 1 回あたり約 0.33〜0.34 ms の LED 通信が入ります。  
> `BTN_BUILTIN` はプルダウン式で **押すと HIGH** です(一般的な Arduino のプルアップ式とは逆)。  

---

## データ記憶領域

AVR64DU32 には用途の異なる複数の不揮発メモリ領域があります。  
ATmega と比べて EEPROM は小さくなりましたが（256 B）、代わりに **USERROW（使用者列）** などの新しい領域が使えます。  

| 領域 | 容量 | 消去単位 | 書き換え耐久 | チップ消去(再書き込み)で | 対応ライブラリ |
|------|------|----------|--------------|----------------------------|----------------|
| EEPROM | 256 B | バイト(1–32 B) | 10 万回 | 消える(EESAVE ヒューズで保持可) | `EEPROM.h` |
| USERROW | 512 B | 512 B ページ一括 | 1,000 回 | **残る** | `USERSIG.h` |
| Flash(APPDATA) | スケッチ領域の空き | 512 B ページ | 1,000 回 | 消える | `Flash.h` |
| SIGROW | 読み取り専用 | — | — | — | 工場書き込みの 16 B 個体シリアル番号を含む |

<sub>各領域の仕様・耐久回数はデータシート DS40002548A(§8 Memories/§11 NVMCTRL/電気的特性)に基づく。</sub>

---

## ベンチマークテスト

他互換機種とのベンチマークテストの結果です。  

| 機種 | MCU | Clock(MHz) | Dhrystone 2.1(5回平均) |
|------|------|------|------|
| UkiUkiduino | AVR64DU32 | 24.0 | 28931.556 |
| Arduino Uno R3 | ATmega328P | 16.0 | 17307.590 |
| Arduino Leonardo | ATmega32U4 | 16.0 | 17207.268 |

---

## クロック

- UkiUkiduino は **水晶を搭載しない**設計で、システムクロックは内蔵 OSCHF から生成します(既定 **24 MHz**。下記の選択肢参照)。
- USB 用の 48 MHz(CLK_USB)は内蔵 PLL48M が生成し、USB の SOF に同期して自動調整されるため水晶なしでも USB は仕様通りに機能します。

> USB ホスト切断時は動作クロックの精度が内蔵オシレータ単体の精度になります。  

---

### クロック速度の選択肢

Arduino IDE の「ツール > Clock Speed」で次の 2 つを選べます。

| メニュー | F_CPU | 主な用途 |
|---------|-------|---------|
| 24 MHz internal(既定) | 24 MHz | 通常はこちら |
| 16 MHz internal | 16 MHz | classic AVR(16 MHz)とのタイミング互換、省電力 |

> PWM の周波数と `delayMicroseconds()` などの時間処理は F_CPU に追従します。  
> `millis()` / `micros()` はどちらの選択肢でも正しく動作します。  

---

## 書き込み

- 通常は **USB ブートローダ**(USB-CDC / STK500v1)経由で書き込みます。1200 bps タッチで自動的にブートローダへ入ります。
- ブートローダに手動で入るには、RESET ボタンを **ダブルタップ**します(オンボードのフルカラー LED が黄色にブレス点灯します)。
- ブートローダ自体の書き換え(**ツール > ブートローダを書き込む**)には UPDI プログラマが必要です。

---

## ボード / MCU 識別マクロ

| マクロ |  用途 |
|--------|------|
| `ARDUINO_AVR_UKIUKIDUINO` | ボード識別用(UkiUkiduino) |
| `ARDUINO_AVR_UKIUKIDUINO_PONY` | ボード識別用(UkiUkiduino Pony) |
| `__AVR_AVR64DU32__` | MCU 識別用 |
| `__AVR_DU__` | 製品グループ `"DU"` 識別用 |

```cpp
#if defined(ARDUINO_AVR_UKIUKIDUINO_PONY)
  // UkiUkiduino Pony 固有の処理
#elif defined(ARDUINO_AVR_UKIUKIDUINO)
  // Uno R3 形 UkiUkiduino 固有の処理
#endif
```

---

## ライセンスとクレジット

UkiUkiCore は [WazamonoCore](https://github.com/ws-asahi/WazamonoCore)（© Workshop Asahi、[DxCore](https://github.com/SpenceKonde/DxCore)（© Spence Konde、LGPL 2.1）からの派生）をベースにした **製品専用フォーク**です。本コアも **LGPL 2.1** で配布されます。

- ベースコア: **DxCore** - © Spence Konde 2021–2022、および各 Arduino コア
- USB スタック・Wazamono 向けカスタマイズ: © Workshop Asahi 2026
- UkiUkiduino 向けボード定義・カスタマイズ: © Unicollabo

ライセンス全文は [LICENSE.md](LICENSE.md) を参照してください。一部のファイル・ライブラリは別ライセンスで提供される場合があり、その旨は各ファイル先頭に記載されています。

### ハードウェア設計データ

基板の設計データ(KiCad の回路図・基板レイアウト、部品表)は [hardware/](hardware/) にあり、**CERN-OHL-P v2** で公開しています(© Unicollabo)。ライセンス全文は [hardware/LICENSE](hardware/LICENSE)、対象外のファイルなどの詳細は [hardware/README.md](hardware/README.md) を参照してください。

## KiCad design hardware/UkiUkiduinoPony/UkiUkiduinoPony_Schematics.kicad_pcb

File hardware/README.md:

# UkiUkiduino シリーズ ハードウェア設計データ

UkiUkiduino シリーズの基板設計データ(KiCad プロジェクト)です。
ファームウェア(Arduino コア・ブートローダー)はリポジトリ直下の [`megaavr/`](../megaavr/) にあります。

| ディレクトリ | 製品名 | 概要 | Rev. |
|--------------|--------|------|------|
| [`UkiUkiduino/`](UkiUkiduino/) | UkiUkiduino | AVR64DU32 / Arduino Uno R3 互換 / USB-C | 0.6 |
| [`UkiUkiduinoPony/`](UkiUkiduinoPony/) | UkiUkiduino Pony | AVR64DU32 / Pro Micro 互換 / USB-C | 0.2 |

各ディレクトリには次のファイルが入っています。

- `*.kicad_pro` / `*.kicad_sch` / `*.kicad_pcb` - KiCad 10 のプロジェクト・回路図・基板レイアウト
- `*_BOM_JLCPCB.csv` - 部品表(JLCPCB 形式)
- `*ピン構成.csv` - MCU ピンと Arduino ピン番号の対応表
- `libs/` - プロジェクトローカルの部品ライブラリ

## ライセンス

このディレクトリの設計データは **CERN Open Hardware Licence Version 2 - Permissive
(CERN-OHL-P v2)** で公開しています。全文は [LICENSE](LICENSE) を参照してください。

    Copyright Unicollabo 2026.

    This source describes Open Hardware and is licensed under the CERN-OHL-P v2.

    You may redistribute and modify this source and make products using it
    under the terms of the CERN-OHL-P v2 (https://cern.ch/cern-ohl).

    This source is distributed WITHOUT ANY EXPRESS OR IMPLIED WARRANTY,
    INCLUDING OF MERCHANTABILITY, SATISFACTORY QUALITY AND FITNESS FOR A
    PARTICULAR PURPOSE. Please see the CERN-OHL-P v2 for applicable conditions.

リポジトリのその他の部分(Arduino コア・ブートローダーなど)は LGPL 2.1 です。
[../LICENSE.md](../LICENSE.md) を参照してください。

### CERN-OHL-P v2 の対象に含まれないもの

次のものは第三者に由来するため、上記ライセンスの対象ではありません。それぞれの提供元の条件に従います。

- **`libs/lcsc/` 以下の部品データ(シンボル・フットプリントなど)** - LCSC / EasyEDA の部品ライブラリから
  取り込んだものです。再配布・再利用の条件は提供元の利用規約を確認してください。
- **KiCad 標準ライブラリ由来のシンボル・フットプリント** - KiCad Libraries License
  (CC BY-SA 4.0 + 設計データへの適用を除外する例外条項)に従います。
- **キャラクター「浮々ゆにこ」の名称・イラストなどのアートワーク** - このリポジトリには含めていません。
  製品に印刷しているイラストは本ライセンスの対象外です。

Parts:
C1: 4.7μF; C_0603_1608Metric
C2, C4: 10μF; C_0603_1608Metric
C3: 22μF; C_0805_2012Metric
C6, C7, C9, C10: 0.1μF; C_0402_1005Metric
C8: 0.47μF; C_0603_1608Metric
D1: USBLC6-2SC6; SOT-23-6
D2: B5819W SL; C8598_SOD-123_L2_7-W1_6-LS3_7-RD-1; LCSC C8598
D3: LED PWR; LED_0603_1608Metric
D4: XL-5050RGBC-WS2812B; C2843785_LED-SMD_4P-L5_0-W5_0-BL_XL-5050RGBC; LCSC C2843785
J1: L-Side 12pin header; PinHeader_1x12_P2.54mm_Vertical_EdgeCutR
J2: R-Side 12pin header; PinHeader_1x12_P2.54mm_Vertical_EdgeCutL
J3: UPDI v2; PinHeader_1x04_P2.54mm_Vertical
KEY1: RESET; C720477_SW-SMD_L3_9-W3_0-P4_45; LCSC C720477
KEY2: BTN_BUILTIN; C720477_SW-SMD_L3_9-W3_0-P4_45; LCSC C720477
R1, R2, R9, R10: 5.1K; R_0402_1005Metric
R4: 1; R_0603_1608Metric
R7, R8: 330; R_0402_1005Metric
U1: AVR64DU32T-I/RXB; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm
U2: CH213K; C5456874_SOT-23-3_L2_9-W1_6-P1_90-LS2_8-BR; LCSC C5456874
U3: SPX3819M5-L-5-0/TR; C13417_SOT-23-5_L3_0-W1_7-P0_95-LS2_8-BL; LCSC C13417
USB1: CX90M-16P; C2889324_USB-C-SMD_CX90M-16P; LCSC C2889324

Connections:
+5V: C2.1, C4.1, C6.1, C9.1, C10.1, D3.2 (A), D4.1 (VDD), J2.4, J3.2, KEY2.1, U1.18 (VDD), U1.28 (VDD), U2.2 (VO-), U3.5 (OUT)
A0: J2.8, U1.17 (VREFA/PD7)
A1: J2.7, U1.20 (XTAL32K1/PF0)
A2: J2.6, U1.21 (XTAL32K2/PF1)
A3: J2.5, U1.22 (PF2)
BTN_BUILTIN: KEY2.2, R9.1, U1.31 (PA1)
CC1: R1.1, USB1.A5 (CC1)
CC2: R2.1, USB1.B5 (CC2)
D0: J1.2, U1.3 (PA5)
D1: J1.1, U1.2 (PA4)
D2: J1.5, U1.32 (PA2)
D3: J1.6, U1.1 (PA3)
D4: J1.7, U1.9 (PC3)
D5: J1.8, U1.10 (PD0)
D6: J1.9, U1.11 (PD1)
D7: J1.10, U1.4 (PA6)
D8: J1.11, U1.5 (PA7)
D9: J1.12, U1.12 (PD2)
D10: J2.12, U1.13 (PD3)
D14: J2.10, U1.15 (PD5)
D15: J2.9, U1.16 (PD6)
D16: J2.11, U1.14 (PD4)
D+: D1.4 (I/O2), U1.8 (DP)
D-: D1.6 (I/O1), U1.7 (DM)
DM: D1.1 (I/O1), USB1.A7 (DN1), USB1.B7 (DN2)
DP: D1.3 (I/O2), USB1.A6 (DP1), USB1.B6 (DP2)
GND: C1.2, C2.2, C3.2, C6.2, C7.2, C8.2, C9.2, C10.2, D1.2 (GND), D4.3 (GND), J1.3, J1.4, J2.2, J3.3, KEY1.2, R1.2, R2.2, R4.2, R9.2, R10.2, U1.19 (GND), U1.29 (GND), U1.33 (GND), U2.1 (GND), U3.2 (GND), USB1.25 (SHELL), USB1.26 (SHELL), USB1.27 (MD), USB1.28 (MD), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND)
LED_BUILTIN: R8.2, U1.30 (PA0)
unnamed: C4.2, R4.1
unnamed: C3.1, D2.1 (-), U3.1 (IN), U3.3 (EN)
unnamed: D3.1 (K), R10.1
unnamed: D4.4 (DIN), R8.1
unnamed: C8.1, U1.6 (VUSB)
RESET: C7.1, J3.1, R7.2, U1.26 (~RESET/PF6)
RST: J2.3, KEY1.1, R7.1
UPDI: J3.4, U1.27 (UPDI)
VBUS: C1.1, D1.5 (VBUS), U2.3 (VI+), USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)
VIN: D2.2 (+), J2.1

Notes on the sheet:
D3,4,7のPWMは両方TCB1＋LUT-OUTを使用するのでいずれか一つのみ使用可 またServoやToneでTCB1を利用する場合は全て使用不可
理想ダイオード USBバスパワー駆動時も5Vに近い電圧を供給可
RAW(外部入力電圧7～24V) Tachiは電圧をそのまま流すRAWではなく 5V生成用LDOを通すVINを実装する 外部電源をそのまま使用する場合は VINではなくVCCへ5Vを入力すること USBバスからの電圧はU3を逆流してRAWへ出力される

Board: 2 copper layers, 35.0 x 17.8 mm, 29 parts (2 on the bottom side), 38 nets.

## KiCad design hardware/UkiUkiduino/UkiUkiduino_Schematics.kicad_pcb

Parts:
C1, C2, C7, C9, C10: 0.1μF; C_0402_1005Metric
C3, C4, C5, C6: 22μF; C_0805_2012Metric
C8: 0.47μF; C_0603_1608Metric
D1: USBLC6-2SC6; SOT-23-6
D2: SS34; D_SMA
D3: LED PWR; LED_0603_1608Metric
D4: WS2812D-F5-12MA-C1; C4154875_LED-TH_4P-BD5_8-P1_27_WS2812D-F5-12MA-C1; LCSC C4154875
DC1: DC-005-2.5A-2.0; C319099_CONN-TH_DC-005-2_5A-2_0; LCSC C319099
J1: Power/Analog; PinSocket_1x15_P2.54mm_Vertical_Arduino_6+8
J2: Digital/PWM; PinSocket_1x18_P2.54mm_Vertical_Arduino_8+10
J5: ICSP; PinHeader_2x03_P2.54mm_Vertical
KEY1: RESET; C273519_KEY-SMD_4P-L6_0-W6_0-P4_50-LS10_0; LCSC C273519
KEY2: BTN_BUILTIN; C273519_KEY-SMD_4P-L6_0-W6_0-P4_50-LS10_0; LCSC C273519
R1, R2, R9, R10: 5.1K; R_0402_1005Metric
R3, R4, R5, R6: 1; R_0603_1608Metric
R7: 330; R_0402_1005Metric
R8: 75; R_0603_1608Metric
U1: AVR64DU32-I/RXB; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm
U2: XC8110AA01MR-G; C3235547_TSOT-25_L2_9-W1_6-P0_95-LS2_8-BR; LCSC C3235547
U3: AMS1117-5.0; C6187_SOT-223_L6_5-W3_5-P2_30-LS7_0-BR; LCSC C6187
U4: AMS1117-3.3; C6186_SOT-223-3_L6_5-W3_4-P2_30-LS7_0-BR; LCSC C6186
USB1: TYPE-C-31-M-12; C165948_USB-C_SMD-TYPE-C-31-M-12_1; LCSC C165948

Connections:
+3V3: C6.1, J1.4, U4.2 (VOUT), U4.4 (VOUT)
+5V: C2.1, C4.1, C5.1, C9.1, C10.1, D3.2 (A), D4.2 (VDD), J1.2, J1.5, J5.2, KEY2.4, U1.18 (VDD), U1.28 (VDD), U2.5 (VOUT), U3.2 (VOUT), U3.4 (VOUT), U4.3 (VIN)
A0: J1.10, U1.20 (XTAL32K1/PF0)
A1: J1.11, U1.21 (XTAL32K2/PF1)
A2: J1.12, U1.22 (PF2)
A3: J1.13, U1.23 (PF3)
A4: J1.14, J2.2, U1.32 (PA2)
A5: J1.15, J2.1, U1.1 (PA3)
AREF: J2.3, U1.17 (VREFA/PD7)
BTN_BUILTIN: KEY2.2, R9.2, U1.31 (PA1)
CC1: R1.1, USB1.A5 (CC1)
CC2: R2.1, USB1.B5 (CC2)
D0: J2.18, U1.3 (PA5)
D1: J2.17, U1.2 (PA4)
D2: J2.16, U1.5 (PA7)
D3: J2.15, U1.4 (PA6)
D4: J2.14, U1.9 (PC3)
D5: J2.13, U1.10 (PD0)
D6: J2.12, U1.11 (PD1)
D7: J2.11, U1.25 (PF5)
D8: J2.10, U1.24 (PF4)
D9: J2.9, U1.12 (PD2)
D10: J2.8, U1.13 (PD3)
D11: J2.7, J5.4, U1.14 (PD4)
D12: J2.6, J5.1, U1.15 (PD5)
D13: J2.5, J5.3, U1.16 (PD6)
D+: D1.4 (I/O2), U1.8 (DP)
D-: D1.6 (I/O1), U1.7 (DM)
DN: D1.1 (I/O1), USB1.A7 (DN1), USB1.B7 (DN2)
DP: D1.3 (I/O2), USB1.A6 (DP1), USB1.B6 (DP2)
GND: C1.2, C2.2, C7.2, C8.2, C9.2, C10.2, D1.2 (GND), D4.3 (GND), DC1.2, DC1.3, J1.6, J1.7, J2.4, J5.6, KEY1.1, KEY1.2, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R9.1, R10.2, U1.19 (GND), U1.29 (GND), U1.33 (GND), U2.2 (VSS), U3.1 (GND), U4.1 (GND), USB1.1 (EH), USB1.2 (EH), USB1.3 (EH), USB1.4 (EH), USB1.A1B12 (GND), USB1.B1A12 (GND)
LED_BUILTIN: R8.2, U1.30 (PA0)
unnamed: C3.2, R3.1
unnamed: C4.2, R4.1
unnamed: C5.2, R5.1
unnamed: C6.2, R6.1
unnamed: C3.1, D2.1 (K), U3.3 (VIN)
unnamed: D3.1 (K), R10.1
unnamed: D4.4 (Din), R8.1
unnamed: C8.1, U1.6 (VUSB)
RESET: C7.1, J1.9, R7.2, U1.26 (~RESET/PF6)
RST: J1.3, J5.5, KEY1.3, KEY1.4, R7.1
UPDI: J1.1, U1.27 (UPDI)
VBUS: C1.1, D1.5 (VBUS), U2.1 (VIN), U2.3 (CE), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
VIN: D2.2 (A), DC1.1, J1.8

Notes on the sheet:
理想ダイオード USBバスパワー駆動時も5Vに近い電圧を供給可
VIN(外部入力電圧7～12V)
D3,4,8のPWMは両方TCB1＋LUT-OUTを使用するのでいずれか一つのみ使用可 またServoやToneでTCB1を利用する場合は全て使用不可

Board: 2 copper layers, 68.6 x 53.3 mm, 39 parts (0 on the bottom side), 45 nets.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_3.2mm

## Code that names these connections

File megaavr/variants/UkiUkiduinoPony/pins_arduino.h (part):

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 *           official fan goods of the VTuber Yuniko Ukiuki). Hardware Rev.0.2:
 *           the Wazamono Tachi rev.5 header layout with the UkiUkiduino
 *           on-board user button and full-color LED. The LED data line and
 *           the button sit on PA0 / PA1 - the same MCU pins as on the
 *           Uno-form UkiUkiduino.
 * MCU     : AVR64DU32  (32-pin VQFN, AVR64DU32-I/RXB; same pinout as the TQFP)
 * Power   : +5V rail fed from USB VBUS through a CH213K ideal diode, or from
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 * Clock   : internal OSCHF, 24 MHz default (no crystal on the board; boards.txt
 *           pins build.clocksource=0). USB CLK_USB (48 MHz) is produced by
 *           OSCHF + PLL48M and auto-tuned to the USB SOF.
 *           PA0/PA1 (the XTALHF pads) carry the LED data line and the button.
 *
 *  ===== Pin numbering: Pro Micro compatible (NONCANONICAL) =====
 *  (source: hardware/UkiUkiduinoPony/UkiUkiduinoPony.net +
 *           UkiUkiduinoPony_ProMicro互換用ピン構成.csv, Rev.0.2)
 *   D#   MCU   Pro Micro role / notes                          A#,  AIN
 *   D0   PA5   RX  (Serial1 = USART0 RX, ALT1)                 A11, AIN25
 *   D1   PA4   TX  (Serial1 = USART0 TX, ALT1)                 A12, AIN24
 *   D2   PA2   SDA (I2C)                                       A13, AIN22
 *   D3   PA3   SCL (I2C) | ~PWM(TCB1 WO, default outlet)       A14, AIN23
 *   D4   PC3   ~PWM(TCB1 via LUT1-OUT) | LUT1-OUT              A6,  AIN31
 *   D5   PD0   ~PWM(TCA0 WO0) | LUT2-IN0                       A15, AIN0
 *   D6   PD1   ~PWM(TCA0 WO1) | LUT2-IN1                       A7,  AIN1
 *   D7   PA6   ~PWM(TCB1 via LUT0-OUT alt) | USART0 XCK        A16, AIN26
 *   D8   PA7   USART0 XDIR | AC0 OUT | EVOUTA | CLKOUT         A8,  AIN27
 *   D9   PD2   ~PWM(TCA0 WO2) | LUT2-IN2 | AINP0 | EVOUTD      A9,  AIN2
 *   D10  PD3   ~PWM(TCA0 WO3) | LUT2-OUT | AINN0               A10, AIN3
 *   D11..D13   (do not exist - gap, like the 32U4 Pro Micro)
 *   D14  PD5   MISO | ~PWM(TCA0 WO5)                           A17, AIN5
 *   D15  PD6   SCK  | Serial2 TX (USART1 ALT2)                 A18, AIN6
 *   D16  PD4   MOSI | ~PWM(TCA0 WO4)                           A19, AIN4
 *   D17  PF3   LED_BUILTIN - state pin of the on-board WS2812B full-color
 *              LED (see LED below). The MCU pin is NOT connected to
 *              anything on the board (no header).              A20, AIN19
 *   D18  PD7   A0 | SPI SS | Serial2 RX (USART1 ALT2) | VREFA       AIN7
 *   D19  PF0   A1 | LUT3-IN0                                        AIN16
 *   D20  PF1   A2 | LUT3-IN1                                        AIN17
 *   D21  PF2   A3 | LUT3-IN2 | EVOUTF                               AIN18
 *        PA0   WS2812B LED data-in (index 22; driven by the D17 software
 *              mirror - not a user pin, no Dn alias)
 *        PF4   not connected on the board (index 23; no Dn alias)
 *        PF5   not connected on the board (index 24; no Dn alias)
 *   D25..D31   (do not exist - gap)
 *   D32  PA1   BTN_BUILTIN (on-board button, 5.1 kOhm pull-down,
 *              pressed = HIGH; no ADC channel) - the family-wide number
 *   --- not exposed as a numbered Dn (appended so the arrays are complete) ---
 *        PF6   RESET                                   index 33
 *        PF7   UPDI                                    index 34  (== PIN_PF7, highest)
 *
 *  ===== Peripheral routing (set by this variant + boards.txt) =====
 *   TCA0  -> PORTD (WO0..WO5 = PD0..PD5 = D5/D6/D9/D10/D16/D14) : TCA0_PINS below
 *            -> classic Pro Micro PWM set D3/D5/D6/D9/D10 is fully reproduced;
 *               D14/D16 gain bonus PWM (mutually exclusive with SPI use).
 *   TCB1  -> ONE waveform, THREE exclusive outlets (WAZAMONO_TCB1_PWMMUX):
 *            D3 = PA3 (TCB1 WO, default PORTMUX position, outlet = CCMPEN),
 *            D7 = PA6 (LUT0-OUT alternate position),
 *            D4 = PC3 (LUT1-OUT default position).
 *            The last analogWrite() among the three owns the route (default D3).
 *   millis-> TCB0  : boards.txt passes -DMILLIS_USE_TIMERB0 so TCB1 is free for D3/D4/D7 PWM
 *   tone()-> TCB1  : shares TCB1 with D3/D4/D7 PWM (tone() suspends them; TCA0 PWM keeps running)
 *   SPI0  -> ALT4 (PD4/PD5/PD6/PD7 = D16/D14/D15/D18), the ONLY position offered:
 *            the DEFAULT position (PA4..PA7) is occupied by USART0/Serial1.
 *            Board is SPI host; chip-selects are user GPIO (auto-SS not used).
 *            SPI client mode (SPISlave library) uses PD7 = A0 as SS.
 *   TWI0  -> default (PA2 SDA / PA3 SCL) = D2/D3, the Pro Micro I2C position.
 *   USART0-> Serial1, ALT1 (PA4 TX / PA5 RX / PA6 XCK / PA7 XDIR) = D1/D0/D7/D8.
 *   USART1-> Serial2, ALT2 (PD6 TX / PD7 RX) = D15/D18. Shares pins with SPI
 *            SCK/SS, so Serial2 and SPI are mutually exclusive.
 *   CCL   -> LUT0: OUT = D7 (alt; IN0 = PA0 is the LED data line, IN1 = PA1 =
 *                  BTN_BUILTIN = D32);
 *            LUT1: OUT = D4 (IN0..IN2 = PC0..PC2 do not exist on the 32-pin part);
 *            LUT2: IN0/IN1/IN2 = D5/D6/D9, OUT = D10, alt OUT = D15;
 *            LUT3: IN0/IN1/IN2 = A1/A2/A3 (D19/D20/D21). Its OUT (PF3) is the
 *                  LED_BUILTIN state pin and reaches no header, so LUT3 has no
 *                  usable pin output on this board (use it through the event
 *                  system or as a feedback/sequencer stage instead).
 *   AREF  -> PD7 (VREFA) doubles as analog input A0 (D18). The Pro Micro has
 *            no AREF header; an external reference would have to be fed into
 *            the A0 pin and costs A0 / SPI SS / Serial2 RX.
 *   LED   -> the user LED is an XL-5050RGBC-WS2812B addressable RGB LED whose
 *            DIN is wired to PA0 through a 330 Ohm series resistor.
 *            LED_BUILTIN is D17 = PF3, an MCU pin that is not connected to
 *            anything on the board and acts as the LED's STATE pin:
 *            digitalWrite()/digitalWriteFast() to D17 are SOFTWARE-mirrored -
 *            the core reads the resulting PF3 OUT bit and sends the matching
 *            WS2812 frame on PA0 (HIGH = lit in the current color, yellow by
 *            default; LOW = off). Because PF3 is a real pin, digitalRead(D17)
 *            returns the LED state, so "digitalWrite(LED_BUILTIN,
 *            !digitalRead(LED_BUILTIN))" toggles as expected (the data line
 *            itself must idle LOW for the WS2812 latch, so it cannot carry the
 *            state). Same mechanism and same setBLEDColor() API as the Uno
 *            UkiUkiduino, and the same data pin (PA0); only LED_BUILTIN's
 *            number (D17 instead of D13) and the LED's byte order differ.
 *            Each mirrored write costs ~330 us (300 us latch guard + 24 us
 *            frame).
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 *            next to the USB connector is a plain power indicator). The
 *            32U4 helper macros TXLED0/TXLED1/RXLED0/RXLED1/TX_RX_LED_INIT
 *            are kept as no-ops so Pro Micro sketches still compile.
 *   BUTTON-> BTN_BUILTIN = D32 (PA1). Same number and same MCU pin as on the
 *            Uno-form UkiUkiduino. 5.1 kOhm pull-down on the board;
 *            pressed = HIGH. Use pinMode(BTN_BUILTIN, INPUT) - no pullup needed.
 *   Serial-> native USB CDC (USBSerial), Leonardo/Micro convention.
 *
 *   NOTE on names: "Serial" is the native USB CDC (serial monitor). The D0/D1
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  #define ARDUINO_AVR_UKIUKIDUINO_PONY 1
#endif
#define DU_32PIN_PINOUT
#define UKIUKIDUINO_PINOUT            /* UkiUkiduino family (LED_BUILTIN mirror + setBLEDColor + BTN_BUILTIN) */
#define UKIUKIDUINO_PONY_PINOUT   /* this board's variant sources */
#define NONCANONICAL_PIN_NUMBERS

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#endif

/* ---- Digital pin number for each MCU pin (Pro Micro layout) ---- */
#define PIN_PA5 (0)   // D0  RX  (Serial1 = USART0 RX)
#define PIN_PA4 (1)   // D1  TX  (Serial1 = USART0 TX)
#define PIN_PA2 (2)   // D2  SDA
#define PIN_PA3 (3)   // D3  SCL / TCB1 PWM (WO, default outlet)
#define PIN_PC3 (4)   // D4  TCB1 PWM via LUT1-OUT
#define PIN_PD0 (5)   // D5  TCA0 WO0
#define PIN_PD1 (6)   // D6  TCA0 WO1
#define PIN_PA6 (7)   // D7  TCB1 PWM via LUT0-OUT (alt) / USART0 XCK
#define PIN_PA7 (8)   // D8  USART0 XDIR / AC0 OUT / EVOUTA / CLKOUT
#define PIN_PD2 (9)   // D9  TCA0 WO2 / AINP0 / EVOUTD
#define PIN_PD3 (10)  // D10 TCA0 WO3 / AINN0
//  no  D11..D13              (gap)
#define PIN_PD5 (14)  // D14 MISO / TCA0 WO5
#define PIN_PD6 (15)  // D15 SCK / Serial2 TX
#define PIN_PD4 (16)  // D16 MOSI / TCA0 WO4
#define PIN_PF3 (17)  // D17 LED_BUILTIN state pin (mirrored to the WS2812B on PA0; pin not connected on the board)
#define PIN_PD7 (18)  // D18 A0 / SPI SS / Serial2 RX / VREFA
#define PIN_PF0 (19)  // D19 A1 / LUT3-IN0
#define PIN_PF1 (20)  // D20 A2 / LUT3-IN1
#define PIN_PF2 (21)  // D21 A3 / LUT3-IN2 / EVOUTF
#define PIN_PA0 (22)  // WS2812B LED data-in (driven by the D17 software mirror); no Dn alias
#define PIN_PF4 (23)  // not connected on the board; no Dn alias
#define PIN_PF5 (24)  // not connected on the board; no Dn alias
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

Notices in the files:
megaavr/variants/UkiUkiduinoPony/pins_arduino.h:
DxCore is (C) Spence Konde 2021-2022, open source (LGPL 2.1, see LICENSE.md),
based on existing Arduino cores. This variant (C) Workshop Asahi 2026.
README.md:
License: LGPL-2.1
